# Keil uVision project lpc1768_ucos-ii_r61505_ov7670.uvproj, settings and files
target src (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lpc1768_ucos-ii_r61505_ov7670 +hex
  c flags: Optim=1
  c include: .\src\cmsis;.\src\ucos-ii\ports;.\src\ucos-ii\source;.\src\ucos-ii\app;.\src\driver;.\src\bsp
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group cmsis
    ./src/cmsis/: core_cm3.c system_LPC17xx.c startup_LPC17xx.s
  group ucos-ii_ports
    ./src/ucos-ii/ports/: os_cpu_a.s os_cpu_c.c os_dbg.c
  group ucos-ii_source
    ./src/ucos-ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos-ii_app
    ./src/ucos-ii/app/: app_hooks.c
  group driver
    ./src/driver/: pin.c uart0.c ssp0.c i2c0.c timer3.c
  group user
    ./src/user/: main.c task.c
  group bsp
    ./src/bsp/: util.c
  group bsp_fatfs
    ./src/bsp/fatfs/: diskio.c ff.c mmc_diskio.c mmc_diskio_port.c
  group bsp_lcd
    ./src/bsp/lcd/: lcd_port.c lcd.c
  group bsp_ov7670
    ./src/bsp/ov7670/: ov7670.c ov7670_port.c
